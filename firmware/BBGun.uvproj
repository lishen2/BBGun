# Keil uVision project BBGun.uvproj, settings and files
target TestBoard1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BBGun +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,DEBUG
  c include: .\libraries\CMSIS\CM3\CoreSupport;.\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\libraries\STM32F10x_StdPeriph_Driver\inc;.\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group library
    ./libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group source
    ./source/: main.c led.c buzzer.c public.c ir.c ringbuf.c usart_io.c button.c switch.c stm32f10x_it.c system_stm32f10x.c
